# Keil uVision project atk_h7r3_full_camrun_fast.uvprojx, settings and files
target atk_h7r3_full_camrun_fast (6220000::V6.22::ARMCLANG)
  device: STM32H7R3L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h7r3_full_camrun_fast +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R3xx
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc\Legacy;..\..\Middlewares;..\..\Middlewares\ST\AI\Inc;..\..\Middlewares\ATKQR\Inc;..\..\User;..\..\Middlewares\LVGL\GUI;..\..\Middlewares\LVGL\GUI\lvgl;..\..\Middlewares\LVGL\GUI\lvgl\src;..\..\Middlewares\LVGL\Font
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\User\Script\ATK-DNH7R3_flash_ROMxspi1_camrun_fast.sct
  link misc: --diag_suppress L6314,L6329
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r3xx.s
  group User
    ../../User/: main.c stm32h7rsxx_it.c
    ../../User/ai/: app_x-cube-ai.c network.c network_data.c network_data_params.c ai_class_labels.c network_weights_bin_fast.s
    ../../User/app/: camera_workflow.c cart_service.c product_catalog.c payment_qr.c payment_qr_test.c
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_sram.c stm32h7rsxx_ll_fmc.c stm32h7rsxx_hal_dcmipp.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/HYPERRAM/: hyperram.c
    ../../Drivers/BSP/NORFLASH/: norflash.c norflash_ex.c norflash_mx25um25645g.c norflash_w25q128_dual.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/HX711/: hx711.c
    ../../Drivers/BSP/DCMIPP/: dcmipp.c
    ../../Drivers/BSP/OV2640/: ov2640.c sccb.c
  group Middlewares/ST/AI
    ../../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
  group Drivers/BSP/ATKQR
    ../../Drivers/BSP/ATKQR/: atk_qrdecode.c ATK_QR_V1.4.lib
  group Readme
    ../../: readme.txt
  group Drivers/BSP/TOUCH
    ..//..//Drivers//BSP//TOUCH//: ctiic.c ft5206.c gt9xxx.c touch.c
  group Drivers/BSP/IIC
    ..//..//Drivers//BSP//IIC//: myiic.c
  group Drivers/BSP/24CXX
    ..//..//Drivers//BSP//24CXX//: 24cxx.c
  group Middlewares/LVGL
    ..//..//Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ..//..//Middlewares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/LVGL/Font
    ..//..//Middlewares//LVGL//Font//: Font20.c
  group User/UI
    ..//..//User//ui//: lvgl_port.c checkout_ui.c
    ..//..//User//ui//icons//: checkout_icons.c
