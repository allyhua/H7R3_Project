# Keil uVision project atk_h7r3_full.uvprojx, settings and files
target atk_h7r3_full (6220000::V6.22::ARMCLANG)
  device: STM32H7R3L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h7r3_full +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R3xx
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc;..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc\Legacy;..\..\Middlewares;..\..\Middlewares\ST\AI\Inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\User\Script\ATK-DNH7R3_flash_ROMxspi1.sct
  link misc: --diag_suppress L6314,L6329 --keep network_weights_bin.o(network_weights_section)
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7r3xx.s
  group User
    ../../User/: main.c app_x-cube-ai.c network.c network_data.c network_data_params.c ai_class_labels.c network_weights_bin.s stm32h7rsxx_it.c
    ../../User/app/: camera_workflow.c
    ../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_sram.c stm32h7rsxx_ll_fmc.c stm32h7rsxx_hal_dcmipp.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/HYPERRAM/: hyperram.c
    ../../Drivers/BSP/NORFLASH/: norflash.c norflash_ex.c norflash_mx25um25645g.c norflash_w25q128_dual.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/HX711/: hx711.c
    ../../Drivers/BSP/DCMIPP/: dcmipp.c
    ../../Drivers/BSP/OV2640/: ov2640.c sccb.c
  group Middlewares/ST/AI
    ../../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
  group Readme
    ../../: readme.txt
